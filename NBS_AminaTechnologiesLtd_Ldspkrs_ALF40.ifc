Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2020-08-25T09:04:54
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.4.0.0 - Alternate UI 18.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Tue Aug 25 09:04:54 2020* Host: NCL-PI04* Database: C:\Users\BocianP\AppData\Local\Temp\{3A745599-72DE-4D8B-962C-C7459908CDF3}\ifc* Database version: 5507* Database creation date: Tue Aug 25 09:04:41 2020* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Tue Aug 25 09:04:53 2020* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Tue Aug 25 09:04:53 2020* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcBuildingElementProxy: ALF40, NBS_AminaTechnologiesLtd_Ldspkrs_ALF40:ALF40:304220
In: Level 0
Type - PredefinedType: USERDEFINED; Classification: Pr_70_75_06_50 (Uniclass2015); Material: NBS_Concept
Type - BOS_General - Author: NBS; BIMObjectName: NBS_AminaTechnologiesLtd_Loudspeakers_ALF40; ManufacturerName: Amina Technologies Ltd; ManufacturerURL: https:/​/​uk.aminasound.com/​; NBSCertification: www.nationalbimlibrary.com/cert/dn4ql5hs; NBSDescription: Loudspeakers; NBSReference: 90-70-10/435; ProductInformation: https://uk.aminasound.com/file-directory/product/subwoofers/alf40/datasheet/ALF40_Datasheet.pdf; Revision: n/a; Uniclass2015Title: Loudspeakers; Uniclass2015Code: Pr_70_75_06_50; Uniclass2015Version: Products v1.18; Version: 1
Type - NBS_Data - LoudspeakerSensitivity: 88dB SPL at 1m / 2.83Vrms (half space); RatedImpedance: 8 ohm; PowerHandlingContinuous: 30W RMS (60W Peak); Dispersion: Omnidirectional; EnclosureFormat: Embedded; CableConnectionsType: Push button spring terminals; CableConnectionsCapacity: 14-16 AWG; PortLocations: Side or end-firing port locations; Weight: 3.2 kg; PortDiameter: 39 mm/ 43 mm (inner/ outer); PortTubeLengthAdjustment: 80 mm
Type - Pset_AudioVisualApplianceTypeCommon - AudioVolume: 103dB SPL at 1m (half space); MediaSource: n/a; Reference: n/a
Type - Pset_AudioVisualApplianceTypeSpeaker - FrequencyResponse: 65Hz – 155 Hz (-6dB) 18dB/octave band-pass; Impedence: 8 ohm; SpeakerDriverSize: n/a; SpeakerType: WOOFER
Type - IFC - IfcExportAs: IfcAudioVisualApplianceType; IfcExportType: SPEAKER
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_70_75_06_50:Loudspeakers; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: High performance discreet bass enhancer utilizing a unique adjustable ported design which easily blends into any room environment by mounting within walls, ceilings, cabinets or other joinery with minimal visual impact; DurationUnit: year; ExpectedLife: n/a; Features: Ideal for distributed audio systems, provided with metal brackets for mounting directly to studs/ joists, designed to be connected directly to a dedicated full range amplifier output, no additional filtering is required when used in conjunction with Amina Invisible loudspeakers; Finish: n/a; Grade: n/a; Manufacturer: sales@aminasound.com; Material: n/a; ModelNumber: ALF40; ModelReference: ALF40; Name: Loudspeakers_ALF40_AminaTechnologiesLtd; NominalWidth: 134 mm; ReplacementCost: n/a; Shape: Rectangular; Size: 359 x 157 x 134 mm; SustainabilityPerformance: n/a; WarrantyDescription: Manufacturer limited warranty; WarrantyDurationLabor: 0; WarrantyDurationParts: 3; WarrantyDurationUnit: year; WarrantyGuarantorLabor: Installer; WarrantyGuarantorParts: Amina Technologies Ltd
COBie - NominalHeight: 359 mm; NominalLength: 157 mm; AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcDistributionPort, Port_304220
Description: Flow; FlowDirection: SOURCEANDSINK
